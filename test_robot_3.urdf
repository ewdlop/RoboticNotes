Commit message: trying out cartpole urdf file.

File: test_robot_3.urdf (robot description, URDF)
Before this commit: robot test_robot_3, 2 links, 1 joints
Joints:
- joint base_to_arm: axis 0 0 1 -> 1 0 0
